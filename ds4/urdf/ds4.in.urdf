Commit message: fix: include ds4 controller in collision

File: ds4/urdf/ds4.in.urdf (robot description, URDF)
Before this commit: robot ds4, 3 links, 2 joints
Links:
- link ds4_actual_controller_link: geometry collision box size=0.14 0.03 0.06; visual box size=0.14 0.03 0.06
