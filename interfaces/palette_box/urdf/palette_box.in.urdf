Commit message: feat(stl): resize stl

File: interfaces/palette_box/urdf/palette_box.in.urdf (robot description, URDF)
Before this commit: robot palette_box, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=0.02 0.6 0.7; collision box size=0.02 0.6 0.7
